# Keil uVision project direct_test_mode_s110_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_DEFINES_ONLY BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s110\headers
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00016000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group Modules
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
