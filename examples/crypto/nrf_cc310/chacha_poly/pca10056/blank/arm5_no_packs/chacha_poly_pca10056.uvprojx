# Keil uVision project chacha_poly_pca10056.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: DEBUG_NRF DEBUG DX_CC_TEE CHACHA_INTEGTEST NRF_LOG_USES_RTT=1 NRF_LOG_ENABLED=1 NRF_SDK_PRESENT __STACK_SIZE=2048 NRF52840_XXAA CONFIG_GPIO_AS_PINRESET BOARD_PCA10056 BSP_DEFINES_ONLY SEGGER_RTT_BLOCKING NRF_LOG_BACKEND_RTT_OUTPUT_BUFFER_SIZE=2048
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\..\external\nrf_cc310\common;..\..\..\..\..\..\..\external\nrf_cc310\include;..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DDEBUG_NRF,-DDEBUG,-DDX_CC_TEE,-DCHACHA_INTEGTEST,-DNRF_LOG_USES_RTT=1,-DNRF_LOG_ENABLED=1,-DNRF_SDK_PRESENT,-D__STACK_SIZE=2048,-DNRF52840_XXAA,-DCONFIG_GPIO_AS_PINRESET,-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DSEGGER_RTT_BLOCKING,-DNRF_LOG_BACKEND_RTT_OUTPUT_BUFFER_SIZE=2048
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group None
    ../../../../../../../external/nrf_cc310/common/: integration_test_plat_utils.c
  group Application
    ../../../: integration_test_cc_chacha_poly_vectors.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Documentation
    ../../../: license.txt
  group nRF_Libraries
    ../../../../../../../components/libraries/util/: app_util_platform.c nrf_assert.c sdk_errors.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nrf_cc310
    ../../../../../../../external/nrf_cc310/lib/: cc310_keil_0.9.0.lib
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
