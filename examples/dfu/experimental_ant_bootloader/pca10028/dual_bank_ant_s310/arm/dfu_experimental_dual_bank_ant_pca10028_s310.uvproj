# Keil uVision project dfu_experimental_dual_bank_ant_pca10028_s310.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 NRF51 BOARD_PCA10028 ANT_STACK_SUPPORT_REQD BLE_STACK_SUPPORT_REQD S310 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\include;..\..\..\libs\include;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\toolchain;..\..\..\;..\..\..\..\..\bsp;..\..\..\..\..\..\components\softdevice\s310\headers
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3B800 size 0x4800
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: antfs.c antfs_ota.c bootloader.c bootloader_util_arm.c crc.c debug_pin.c dfu_dual_bank.c dfu_transport_ant.c license.txt main.c
    ../../../libs/: app_scheduler.c app_timer.c nrf_delay.c nrf_nvmc.c pstorage.c softdevice_handler.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
