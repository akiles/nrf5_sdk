# IAR project secure_dfu_serial_s132_pca10040_debug.ewp, settings and files
configuration nrf52832_xxaa_s132 (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; NRF52; NRF52832_XXAA; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; NRF52_PAN_55; NRF52_PAN_58; NRF52_PAN_64; NRF52_PAN_74; NRF_DFU_DEBUG_VERSION; NRF_DFU_SETTINGS_VERSION=1; NRF_SD_BLE_API_VERSION=4; S132; SOFTDEVICE_PRESENT; SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION; SWI_DISABLE0; __HEAP_SIZE=0
  ICCARM.CCIncludePath2: ..\..\..\config\secure_dfu_serial_s132_pca10040_debug; ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\ble\common; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\drivers_nrf\clock; ..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\drivers_nrf\rng; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\libraries\bootloader; ..\..\..\..\..\..\components\libraries\bootloader\dfu; ..\..\..\..\..\..\components\libraries\bootloader\serial_dfu; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\crc32; ..\..\..\..\..\..\components\libraries\crypto; ..\..\..\..\..\..\components\libraries\crypto\backend\micro_ecc; ..\..\..\..\..\..\components\libraries\crypto\backend\nrf_crypto_sw; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\fstorage; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\mem_manager; ..\..\..\..\..\..\components\libraries\queue; ..\..\..\..\..\..\components\libraries\scheduler; ..\..\..\..\..\..\components\libraries\sha256; ..\..\..\..\..\..\components\libraries\slip; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\svc; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\..\components\softdevice\s132\headers; ..\..\..\..\..\..\components\softdevice\s132\headers\nrf52; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..\..\dfu_req_handling; ..\..\..; ..\..\..\..\..\..\external\micro-ecc\micro-ecc; ..\..\..\..\..\..\external\nano-pb; ..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure_dfu_serial_s132_pca10040_debug.hex
  ILINK.IlinkOutputFile: secure_dfu_serial_s132_pca10040_debug.out
  ILINK.IlinkIcfFile: secure_dfu_serial_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group None
    ../../../../dfu_req_handling/: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c
  group nRF_micro_ecc
    ../../../../../../external/micro-ecc/nrf52_iar/armgcc/: micro_ecc_lib_nrf52.a
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/crc32/: crc32.c
    ../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../../components/libraries/sha256/: sha256.c
    ../../../../../../components/libraries/slip/: slip.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../components/drivers_nrf/hal/: nrf_nvmc.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group nRF_crypto
    ../../../../../../components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nano-pb
    ../../../../../../external/nano-pb/: pb_common.c pb_decode.c
  group nRF_SERIAL_DFU
    ../../../../../../components/libraries/bootloader/serial_dfu/: nrf_serial_dfu.c
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_crypto_backend
    ../../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../../../../../../components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_Bootloader
    ../../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../../../../../../components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
