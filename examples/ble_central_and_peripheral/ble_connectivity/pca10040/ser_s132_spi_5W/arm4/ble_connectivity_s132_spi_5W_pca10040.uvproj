# Keil uVision project ble_connectivity_s132_spi_5W_pca10040.uvproj, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 NRF52_PAN_58 NRF52_PAN_64 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 S132 NRF_SD_BLE_API_VERSION=5 SER_CONNECTIVITY BSP_DEFINES_ONLY NRF52832 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config\ble_connectivity_s132_spi_5W_pca10040;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\serialization\common;..\..\..\..\..\..\components\serialization\common\struct_ser\s132_s140;..\..\..\..\..\..\components\serialization\common\transport;..\..\..\..\..\..\components\serialization\common\transport\ser_phy;..\..\..\..\..\..\components\serialization\common\transport\ser_phy\config;..\..\..\..\..\..\components\serialization\connectivity;..\..\..\..\..\..\components\serialization\connectivity\codecs\common;..\..\..\..\..\..\components\serialization\connectivity\codecs\s132_s140\middleware;..\..\..\..\..\..\components\serialization\connectivity\codecs\s132_s140\serializers;..\..\..\..\..\..\components\serialization\connectivity\hal;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_55,-DS132,-DNRF_SD_BLE_API_VERSION=5,-DSER_CONNECTIVITY,-DBSP_DEFINES_ONLY,-DNRF52832,-DNRF52,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x2000bcc0 size 0x4340
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52.s
    ../../../../../../components/toolchain/: system_nrf52.c
  group Documentation
    ../../../: license.txt
  group nRF_BLE
    ../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c ble_dtm_hw_nrf52.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/spi_slave/: nrf_drv_spis.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_Serialization
    ../../../../../../components/serialization/connectivity/codecs/s132_s140/serializers/: ble_conn.c ble_event_enc.c ble_evt_conn.c ble_gap_conn.c ble_gap_evt_conn.c ble_gattc_conn.c ble_gattc_evt_conn.c ble_gatts_conn.c ble_gatts_evt_conn.c ble_l2cap_conn.c ble_l2cap_evt_conn.c conn_ble_gap_sec_keys.c conn_ble_user_mem.c nrf_soc_conn.c
    ../../../../../../components/serialization/connectivity/codecs/common/: ble_dtm_init.c conn_mw.c
    ../../../../../../components/serialization/common/struct_ser/s132_s140/: ble_gap_struct_serialization.c ble_gatt_struct_serialization.c ble_gattc_struct_serialization.c ble_gatts_struct_serialization.c ble_struct_serialization.c nrf_soc_struct_serialization.c
    ../../../../../../components/serialization/common/: ble_serialization.c cond_field_serialization.c ser_dbg_sd_str.c
    ../../../../../../components/serialization/connectivity/codecs/s132_s140/middleware/: conn_mw_ble.c conn_mw_ble_gap.c conn_mw_ble_gattc.c conn_mw_ble_gatts.c conn_mw_ble_l2cap.c conn_mw_nrf_soc.c
    ../../../../../../components/serialization/connectivity/hal/: dtm_uart.c
    ../../../../../../components/serialization/connectivity/: ser_conn_cmd_decoder.c ser_conn_dtm_cmd_decoder.c ser_conn_error_handling.c ser_conn_event_encoder.c ser_conn_handlers.c ser_conn_pkt_decoder.c ser_conn_reset_cmd_decoder.c
    ../../../../../../components/serialization/common/transport/: ser_hal_transport.c
    ../../../../../../components/serialization/common/transport/ser_phy/: ser_phy_spi_5W_slave.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s132_nrf52_5.0.0-1.alpha_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: as above
  output: s132_nrf52_5.0.0-1.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ..\..\..\config\ble_connectivity_s132_spi_5W_pca10040;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x2000bcc0 size 0x4340
