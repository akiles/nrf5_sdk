# Keil uVision project twi_master_with_twis_slave_pca10056.uvproj, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEBUG_NRF NRF52840_XXAA SWI_DISABLE0
  c misc: --c99 --reduce_paths
  c include: ..\..\..\config\twi_master_with_twis_slave_pca10056;..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG_NRF,-DNRF52840_XXAA,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../: eeprom_simulator.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf52840.s
    ../../../../../../components/toolchain/: system_nrf52840.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../components/drivers_nrf/twis_slave/: nrf_drv_twis.c
    ../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../../../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
