# IAR project gzll_dynamic_pairing_device_pca10040.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_SD_HW_RESOURCES; BSP_SIMPLE; NRF52832; NRF52; NRF52_PAN_58; NRF52_PAN_64; BOARD_PCA10040; NRF52_PAN_12; NRF52_PAN_15; NRF52_PAN_20; NRF52_PAN_31; NRF52_PAN_36; NRF52_PAN_51; NRF52_PAN_54; CONFIG_GPIO_AS_PINRESET; NRF52_PAN_55; GAZELL_PRESENT; GAZELL_ALTERNATIVE_RESOURCES; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\..\..\..\..\..\..\components; ..\..\..\..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\..\..\..\components\device; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\common; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\..\..\..\components\proprietary_rf\gzll; ..\..\..\..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\..\..\..\external\segger_rtt; ..\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: gzll_dynamic_pairing_device_pca10040.hex
  ILINK.IlinkOutputFile: gzll_dynamic_pairing_device_pca10040.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\gzp_device_iar_nrf52.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Log
    ../../../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Libraries
    ../../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../../../../../../../../components/libraries/timer/: app_timer.c
  group Board Definition
    ../../../../../../../../../components/boards/: boards.c
  group nRF_Drivers
    ../../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../../../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
  group Board Support
    ../../../../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Segger_RTT
    ../../../../../../../../../external/segger_rtt/: RTT_Syscalls_IAR.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group Documentation
    ../../../: license.txt
  group nRF_Properitary_RF
    ../../../../../../../../../components/proprietary_rf/gzll/iar/: gzll_nrf52_sd_resource_iar.a
    ../../../../../../../../../components/proprietary_rf/gzll/: nrf_gzp.c nrf_gzp_device.c
  group Device
    ../../../../../../../../../components/toolchain/iar/: iar_startup_nrf52.s
    ../../../../../../../../../components/toolchain/: system_nrf52.c
