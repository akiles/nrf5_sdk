# Keil uVision project ble_app_hrs_nfc_central_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF_SD_BLE_API_VERSION=5 NRF52_PAN_58 NRF52_PAN_64 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 CONFIG_GPIO_AS_PINRESET NRF52_PAN_55 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  c include: ..\..\..\config;..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\..\..\..\..\..\..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ac_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ble_pair_msg;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\common;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\ep_oob_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\hs_rec;..\..\..\..\..\..\..\components\nfc\ndef\connection_handover\le_oob_rec;..\..\..\..\..\..\..\components\nfc\ndef\generic\message;..\..\..\..\..\..\..\components\nfc\ndef\generic\record;..\..\..\..\..\..\..\components\nfc\ndef\parser\message;..\..\..\..\..\..\..\components\nfc\ndef\parser\record;..\..\..\..\..\..\..\components\nfc\t2t_parser;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\components\toolchain;..\..\..;..\..\..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\..\..\external\nfc_adafruit_library;..\..\..\..\..\..\..\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DS132,-DNRF_SD_BLE_API_VERSION=5,-DNRF52_PAN_58,-DNRF52_PAN_64,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_55,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x20002020 size 0xdfe0
  group Application
    ../../../: ble_module.c buttons.c main.c nfc_pair_module.c pm_module.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../components/libraries/bsp/: bsp.c bsp_nfc.c
  group Documentation
    ../../../: license.txt
  group Third Parties
    ../../../../../../../external/nfc_adafruit_library/: adafruit_pn532.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../../components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_BLE_Services
    ../../../../../../../components/ble/ble_services/ble_bas_c/: ble_bas_c.c
    ../../../../../../../components/ble/ble_services/ble_hrs_c/: ble_hrs_c.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/crc16/: crc16.c
    ../../../../../../../components/libraries/ecc/: ecc.c
    ../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_NFC
    ../../../../../../../components/nfc/ndef/connection_handover/ac_rec/: nfc_ac_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_oob_advdata/: nfc_ble_oob_advdata.c
    ../../../../../../../components/nfc/ndef/conn_hand_parser/ble_oob_advdata_parser/: nfc_ble_oob_advdata_parser.c
    ../../../../../../../components/nfc/ndef/connection_handover/common/: nfc_ble_pair_common.c
    ../../../../../../../components/nfc/ndef/connection_handover/ble_pair_msg/: nfc_ble_pair_msg.c
    ../../../../../../../components/nfc/ndef/connection_handover/ep_oob_rec/: nfc_ep_oob_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/hs_rec/: nfc_hs_rec.c
    ../../../../../../../components/nfc/ndef/connection_handover/le_oob_rec/: nfc_le_oob_rec.c
    ../../../../../../../components/nfc/ndef/conn_hand_parser/le_oob_rec_parser/: nfc_le_oob_rec_parser.c
    ../../../../../../../components/nfc/ndef/generic/message/: nfc_ndef_msg.c
    ../../../../../../../components/nfc/ndef/parser/message/: nfc_ndef_msg_parser.c nfc_ndef_msg_parser_local.c
    ../../../../../../../components/nfc/ndef/generic/record/: nfc_ndef_record.c
    ../../../../../../../components/nfc/ndef/parser/record/: nfc_ndef_record_parser.c
    ../../../../../../../components/nfc/t2t_parser/: nfc_t2t_parser.c
  group nRF_Segger_RTT
    ../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group nRF_micro_ecc
    ../../../../../../../external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
target flash_s132_nrf52_5.0.0-1.alpha_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s132_nrf52_5.0.0-1.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT9: RAM 0x20002020 size 0xdfe0
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
