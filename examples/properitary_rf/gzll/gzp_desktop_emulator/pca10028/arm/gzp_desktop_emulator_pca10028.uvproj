# Keil uVision project gzp_desktop_emulator_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BSP_UART_SUPPORT BSP_SIMPLE BOARD_PCA10028
  c misc: --c99
  c include: ..\..\config;..\..\;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\bsp;..\..\..\..\..\..\components\properitary_rf\gzll;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\gpiote
  asm define: NRF51 BSP_UART_SUPPORT BSP_SIMPLE BOARD_PCA10028
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x39000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: keyboard_emulator.c main_mouse_keyboard_emulator_nrf51.c mouse_sensor_emulator.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/util/: app_error.c app_util_platform.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/drivers_nrf/hal/: nrf_ecb.c nrf_nvmc.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_Properiary_RF
    ../../../../../../components/properitary_rf/gzll/arm/: gzll_arm.lib
    ../../../../../../components/properitary_rf/gzll/: nrf_gzp.c nrf_gzp_device.c
