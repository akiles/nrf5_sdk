# Keil uVision project ble_app_uart.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_uart +hex
  c flags: Optim=1 uC99=1
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x00016000 size 0x00029000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group ::DEVICE
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../: ble_nus.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_conn_params.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../../Source/app_common/: app_timer.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.0
  cpu: as above
  output: ble_app_uart +hex
  c flags: Optim=1 uC99=1
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD
  c include: as above
  memory RVCT4: ROM 0x00016000 size 0x00009000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group added to the first target's files
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
  group left out of the first target's files
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
