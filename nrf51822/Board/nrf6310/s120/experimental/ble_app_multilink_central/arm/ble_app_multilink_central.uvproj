# Keil uVision project ble_app_multilink_central.uvproj, settings and files
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_multilink_central +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\..\Include\s120;..\..\..\..\..\..\include\boards;..\..\..\..\..\..\include\sd_common;..\..\..\experimental;..\..\common;..\..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x00018000 size 0x00027000
  memory RVCT9: RAM 0x20002800 size 0x00001800
  group Startup Code
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: client_handling.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../../Source/ble/: ble_debug_assert_handler.c
    ../../../../../../Source/app_common/: app_trace.c pstorage.c
    ../../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../../Source/ble/device_manager/experimental/: device_manager_central.c
    ../../common/: ble_db_discovery.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_multilink_central +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x00018000 size 0x00007000
  memory RVCT9: RAM 0x20002800 size 0x00001800
