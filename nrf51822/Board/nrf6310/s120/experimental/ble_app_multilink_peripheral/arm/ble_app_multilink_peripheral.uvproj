# Keil uVision project ble_app_multilink_peripheral.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_multilink_peripheral +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BOARD_PCA10001 BLE_STACK_SUPPORT_REQD S110
  c misc: --c99
  c include: ..;..\..\..\..\..\..\Include\ble;..\..\..\..\..\..\Include\ble\device_manager;..\..\..\..\..\..\Include\ble\ble_services;..\..\;..\..\..\..\..\..\Include\s110;..\..\..\..\..\..\Include\boards;..\..\..\..\..\..\Include\sd_common;..\..\..\..\..\..\Include\app_common;..\..\..\..\..\..\Include;..\..\..\..\..\..\Include\sdk
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
  group Services
    ../../../../../../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../../../../../../Source/ble/: ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c
    ../../../../../../Source/app_common/: app_scheduler.c app_timer.c app_button.c app_gpiote.c pstorage.c
    ../../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../../Source/ble/device_manager/: device_manager_peripheral.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_multilink_peripheral +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
