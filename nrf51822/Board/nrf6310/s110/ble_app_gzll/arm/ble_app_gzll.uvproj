# Keil uVision project ble_app_gzll.uvproj, settings and files
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs_w_gzll +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\gzll; ..\..\..\..\..\Include\sd_common
  library: MicroLIB
  memory RVCT4: ROM 0x00014000 size 0x0002B000
  memory RVCT9: RAM 0x20002000 size 0x00002000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: ble_app_gzll_device.c ble_app_gzll_hr.c ble_app_gzll_ui.c ble_gzll_app_timer.c
  group Ble_services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
  group Ble
    ../../../../../Source/ble/: ble_conn_params.c ble_error_log.c ble_advdata.c ble_sensorsim.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/app_common/: pstorage.c crc16.c
  group lib_gzll
    ../../../../../lib/gzll/arm/: gzll_arm.lib
  group Libraries
    ../../../../../Source/app_common/: app_button.c app_gpiote.c
    ../../../../../Source/ble/: ble_debug_assert_handler.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: as above
  output: ble_app_hrs_w_gzll +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x00014000 size 0x0000B000
  memory RVCT9: RAM 0x20002000 size 0x00002000
